# Keil uVision project HBDC130-05EG-I.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestLED
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\app;..\driver;..\sdk;..\sdk\CMSIS;..\sdk\Peripherals;..\sdk\Peripherals\inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../startup/: startup_gd32f10x_hd.s
  group App
    ../app/: main.c App_Adc.c App_Uart.c
  group Driver
    ../driver/: drv_adc.c drv_Init.c drv_IO.c drv_uart.c drv_Timer.c
  group GD32F10x_Peripheral
    ../sdk/Peripherals/src/: gd32f10x_adc.c gd32f10x_dma.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_misc.c gd32f10x_rcc.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_fmc.c
    ../sdk/CMSIS/: core_cm3.c system_gd32f10x.c
