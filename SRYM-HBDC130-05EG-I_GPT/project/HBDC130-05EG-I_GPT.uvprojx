# Keil uVision project HBDC130-05EG-I_GPT.uvprojx, settings and files
target HBDC130-05EG-I_GPT (ARM-ADS)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HBDC130-05EG-I_GPT +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: GD32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99 --cpu Cortex-M3 -D__MICROLIB -DGD32F10X_HD -DUSE_STDPERIPH_DRIVER
  c include: ..\app;..\protocol;..\driver;..\..\SRYM-HBDC130-05EG-I_V1.0\sdk;..\..\SRYM-HBDC130-05EG-I_V1.0\sdk\CMSIS;..\..\SRYM-HBDC130-05EG-I_V1.0\sdk\Peripherals;..\..\SRYM-HBDC130-05EG-I_V1.0\sdk\Peripherals\inc
  group Application
    ../app/: main.c power_ctrl.c fault_manager.c sensor_manager.c fru_manager.c sdr_manager.c
  group Protocol
    ../protocol/: ipmb_frame.c ipmi_dispatch.c
  group SDK
    ../../SRYM-HBDC130-05EG-I_V1.0/sdk/CMSIS/: startup_gd32f10x_hd.s system_gd32f10x.c
    ../../SRYM-HBDC130-05EG-I_V1.0/sdk/Peripherals/src/: gd32f10x_gpio.c gd32f10x_rcc.c gd32f10x_misc.c gd32f10x_i2c.c gd32f10x_adc.c gd32f10x_dma.c gd32f10x_usart.c
